CIRCUIT C:\Users\Se7en\SRAM 1x1.MSK
*
* IC Technology: CMOS 0.18µm - 6 Metal
*
VDD 1 0 DC 2.00
VData_in 10 0 DC 0 PULSE(0.00 2.00 0.00N 0.00N 0.00N 0.00N)
V12_Vdd/2 12 0 DC 1.00V
VPrecharge 14 0 DC 0 PULSE(0.00 2.00 0.00N 0.00N 0.00N 0.00N)
VRead 15 0 DC 0 PULSE(0.00 2.00 0.00N 0.00N 0.00N 0.00N)
VWrite 16 0 DC 0 PULSE(0.00 2.00 0.00N 0.00N 0.00N 0.00N)
VWord 17 0 DC 0 PULSE(0.00 2.00 0.00N 0.00N 0.00N 0.00N)
VSense 18 0 DC 0 PULSE(0.00 2.00 0.00N 0.00N 0.00N 0.00N)
*
* List of nodes
* "~Sense" corresponds to n°4
* "B_line" corresponds to n°5
* "N6" corresponds to n°6
* "~B_line" corresponds to n°7
* "Q" corresponds to n°8
* "~Q" corresponds to n°9
* "Data_in" corresponds to n°10
* "Data_out" corresponds to n°11
* "Precharge" corresponds to n°14
* "Read" corresponds to n°15
* "Write" corresponds to n°16
* "Word" corresponds to n°17
* "Sense" corresponds to n°18
*
* MOS devices
MN1 13 7 5 0 N1  W= 0.60U L= 0.20U
MN2 0 18 4 0 N1  W= 0.60U L= 0.20U
MN3 12 14 7 0 N1  W= 0.60U L= 0.20U
MN4 7 14 5 0 N1  W= 0.60U L= 0.20U
MN5 12 14 5 0 N1  W= 0.60U L= 0.20U
MN6 11 15 5 0 N1  W= 0.60U L= 0.20U
MN7 5 16 10 0 N1  W= 0.60U L= 0.20U
MN8 0 18 13 0 N1  W= 1.20U L= 0.20U
MN9 7 5 13 0 N1  W= 0.60U L= 0.20U
MN10 8 17 5 0 N1  W= 1.20U L= 0.20U
MN11 0 9 8 0 N1  W= 0.60U L= 0.20U
MN12 9 8 0 0 N1  W= 0.60U L= 0.20U
MN13 7 17 9 0 N1  W= 1.20U L= 0.20U
MP1 1 18 4 1 P1  W= 1.20U L= 0.20U
MP2 6 7 5 1 P1  W= 1.20U L= 0.20U
MP3 6 4 1 1 P1  W= 1.20U L= 0.20U
MP4 7 5 6 1 P1  W= 1.20U L= 0.20U
MP5 1 9 8 1 P1  W= 1.20U L= 0.20U
MP6 9 8 1 1 P1  W= 1.20U L= 0.20U
*
C2 1 0 19.881fF
C4 4 0  1.371fF
C5 5 0  4.874fF
C6 6 0  2.378fF
C7 7 0  4.447fF
C8 8 0  1.979fF
C9 9 0  1.979fF
C10 10 0  1.151fF
C11 11 0  1.151fF
C12 12 0  2.458fF
C13 13 0  1.896fF
C14 14 0  1.114fF
C15 15 0  0.976fF
C16 16 0  0.974fF
C17 17 0  1.032fF
C18 18 0  1.157fF
*
* n-MOS Model 3 :
* low leakage
.MODEL N1 NMOS LEVEL=3 VTO=0.50 UO=380.000 TOX= 4.0E-9
+LD =0.020U THETA=0.200 GAMMA=0.350
+PHI=0.500 KAPPA=0.080 VMAX=100.00K
+CGSO=100.0p CGDO=100.0p
+CGBO= 60.0p CJSW=240.0p
*
* p-MOS Model 3:
* low leakage
.MODEL P1 PMOS LEVEL=3 VTO=-0.60 UO=200.000 TOX= 4.0E-9
+LD =0.010U THETA=0.700 GAMMA=0.400
+PHI=0.200 KAPPA=0.010 VMAX=100.00K
+CGSO=100.0p CGDO=100.0p
+CGBO= 60.0p CJSW=240.0p
*
* Transient analysis
*
* (Winspice)
.options temp=27.0
.control
tran 0.1N 20.00N
print  V(9) V(8) V(11) V(16) V(17) V(7) V(18) V(10) V(14) V(15) V(5) > out.txt
plot  V(9) V(8) V(11) V(16) V(17) V(7) V(18) V(10) V(14) V(15) V(5)
.endc
.END
